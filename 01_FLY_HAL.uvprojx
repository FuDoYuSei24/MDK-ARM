# Keil uVision project 01_FLY_HAL.uvprojx, settings and files
target 01_FLY_HAL (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 01_FLY_HAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Inf/led;../Inf/power;../App/task;../Mid/FreeRTOS;../Mid/FreeRTOS/include;../Mid/FreeRTOS/protable/ARM_CM3;../Mid/FreeRTOS/source;../Common/config;../Common/debug;../Inf/motor;../App/flight;../App/communication;../Inf/2_4g
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ../App/task/: App_Task.c
    ../App/flight/: App_Flight.c
    ../App/communication/: App_Communication.c
  group Mid
    ../Mid/FreeRTOS/: FreeRTOSConfig.h
    ../Mid/FreeRTOS/protable/ARM_CM3/: port.c
    ../Mid/FreeRTOS/protable/MemMang/: heap_4.c
    ../Mid/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Inf
    ../Inf/led/: Inf_LED.c
    ../Inf/power/: Inf_IP5305T.c
    ../Inf/motor/: Inf_Motor.c
    ../Inf/2_4g/: Inf_Si24R1.c
  group Common
    ../Common/config/: Com_Config.c
    ../Common/debug/: Com_Debug.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 4.3.0
